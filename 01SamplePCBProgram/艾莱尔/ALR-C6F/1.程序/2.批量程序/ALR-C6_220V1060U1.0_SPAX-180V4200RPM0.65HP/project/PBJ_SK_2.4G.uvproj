# Keil uVision project PBJ_SK_2.4G.uvproj, settings and files
target PBJ_SK_2.4G (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: PBJ_SK_2.4G +hex
  c flags: Optimize=7 SizeSpeed=1
  c include: ..\Library\Device\Include;..\Library\StdDriver\inc;..\user;..\driver;..\bsp;..\Include;..\common
  group Startup
    ../Startup/: STARTUP.A51
  group driver
    ../driver/: 7_segment.c aip1628.c indecate.c led_disp.c keypad.c keypad_fun.c beep.c
  group User
    ../user/: main.c queue.c uart_frame.c treadmills.c param.c programe.c decode.c
  group BSP
    ../bsp/: isr.c PWM_simple.c Timer01_M1.c uart.c ee_param.c IAP_EEPROM.c
  group common
    ../Common/: Delay.c Common.c
