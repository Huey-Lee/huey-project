# Keil uVision project template.uvprojx, settings and files
target template_Release (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32F005C6PA HDSC
  pack: HDSC.HC32F005.1.0.1
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\..\mcu\common;..\source;..\..\..\driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32f005.s
    ../../../mcu/common/: interrupts_hc32f005.c system_hc32f005.c
  group source
    ../source/: main.c my_flash.c my_gpio.c my_pwm.c aip1628.c 7_segment.c led_disp.c indecate.c beep.c treadmills.c param.c keypad.c keypad_fun.c uart_frame.c decode.c queue.c programe.c
  group driver
    ../../../driver/src/: adc.c adt.c bgr.c bt.c crc.c ddl.c flash.c gpio.c i2c.c lpm.c lvd.c ram.c reset.c spi.c sysctrl.c trim.c uart.c vc.c wdt.c
  group README
    ../: readme.txt
software components: CMSIS:CORE 5.1.1
