# Keil uVision project project.uvprojx, settings and files
target Project (6160000::V6.16::ARMCLANG)
  device: CW32L010F8 WHXY
  pack: WHXY.CW32L010_DFP.1.0.2
  cpu: IRAM(0x20000000,0x01000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 wLevel=3
  c include: ..\..\..\..\IdeSupport\MDK;..\..\..\..\Libraries\inc;..\USER\inc;..\BSP;..\SYSTEM;..\PLATFORM
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --keep=*Handler
  group Startup
    ../../../../IdeSupport/MDK/: startup_cw32l010.s
    ../../../../Libraries/src/: system_cw32l010.c
  group User
    ../USER/src/: main.c interrupts_cw32l010.c
  group Driver
    ../../../../Libraries/src/: cw32l010_sysctrl.c cw32l010_gpio.c cw32l010_btim.c cw32l010_adc.c cw32l010_atim.c cw32l010_flash.c cw32l010_gtim.c cw32l010_systick.c cw32l010_uart.c
  group SYSTEM
    ../SYSTEM/: sys_scheduler.c sys_aerobuf.c
  group BSP
    ../BSP/: bsp_uart.c bsp_timer.c bsp_pwm.c bsp_gpio.c
  group PLATFORM
    ../PLATFORM/: treadmills.c app_remote_demo.c ui_display.c plat_segment.c plat_rf.c plat_rf_store.c plat_beep.c plat_keyfun.c plat_aerolink.c led_driver.c
  group Doc
    ../: readme.txt
  group Utilities
    ../../../../Utilities/: retarget.c
software components: CMSIS:CORE 6.1.1
