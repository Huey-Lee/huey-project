# Keil uVision project HC32F005.uvprojx, settings and files
target uart_int_Release (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HC32F005C6PA HDSC
  pack: HDSC.HC32F005.1.0.1
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: uart_int +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\..\..\mcu\common;..\source;..\..\..\..\driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32f005.s
    ../../../../mcu/common/: system_hc32f005.c interrupts_hc32f005.c
  group source
    ../source/: main.c
  group driver
    ../../../../driver/src/: ddl.c sysctrl.c uart.c bt.c lpm.c gpio.c flash.c adc.c adt.c bgr.c
  group User
    ../source/: my_usart.c MY_TIM.c MY_ADC.c MY_VC.c MY_GPIO.c
  group BSP
    ../source/: ringfifo.c point_fun.c queue.c uart_frame.c
  group Motor
    ../source/: motor.c pid.c motor_speed_pid.c
software components: CMSIS:CORE 5.1.1
